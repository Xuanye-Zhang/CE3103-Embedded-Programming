# Keil uVision project lab.uvproj, settings and files
target HelloWorld (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: practiceA +hex
  c flags: Optim=3 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: .\LibraryFiles\CORE;.\LibraryFiles\STM32F1xx_Driver\inc;.\LibraryFiles\FreeRTOS\include;.\LibraryFiles\FreeRTOS\portable\RVDS\ARM_CM3;.\LibraryFiles\SYSTEM\sys;.\LibraryFiles\SYSTEM\SYSTEM;.\LibraryFiles\SYSTEM\delay;.\LibraryFiles\HARDWARE\LED;.\LibraryFiles\HARDWARE\OLED;.\LibraryFiles\HARDWARE\Buzz;.\LibraryFiles\SYSTEM\show;.\LibraryFiles\HARDWARE\UserButton;.\LibraryFiles\HARDWARE\UART
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group CORE
    ./: startup_stm32f10x_hd.s
    ./LibraryFiles/CORE/: core_cm3.c stm32f10x_it.c system_stm32f10x.c
  group SYSTEM
    ./LibraryFiles/SYSTEM/sys/: sys.c
    ./LibraryFiles/SYSTEM/SYSTEM/: system.c
    ./LibraryFiles/SYSTEM/delay/: delay.c
    ./LibraryFiles/SYSTEM/show/: show.c
  group STM32F1xx_Driver
    ./LibraryFiles/STM32F1xx_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group HARDWARE
    ./LibraryFiles/HARDWARE/LED/: LED.C
    ./LibraryFiles/HARDWARE/OLED/: oled.c
    ./LibraryFiles/HARDWARE/Buzz/: Buzzer.c
    ./LibraryFiles/HARDWARE/UserButton/: userButton.c
    ./LibraryFiles/HARDWARE/UART/: UART.c
  group FREERTOS
    ./LibraryFiles/FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ./LibraryFiles/FreeRTOS/portable/MemMang/: heap_4.c
    ./LibraryFiles/FreeRTOS/portable/RVDS/ARM_CM3/: port.c
  group Main
    ./: main.c
